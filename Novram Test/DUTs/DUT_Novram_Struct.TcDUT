TYPE DUT_Novram_Struct :
STRUCT RETAIN
	s_name: WSTRING;
	i_old: INT;
	s_gender: WSTRING;
	f_height: LREAL;
	f_weight: LREAL;
END_STRUCT
END_TYPE
